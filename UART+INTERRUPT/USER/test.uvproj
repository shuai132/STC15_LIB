# Keil uVision project test.uvproj, settings and files
target Target 1 (MCS-51)
  device: 8052AH Intel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(12000000)
  output: STC15 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Lib\inc;..\Lib\src;..\USER;..\MyDriver
  group Lib
    ../Lib/src/: STC15xx_delay.c STC15xx_GPIO.c STC15xx_USART1.C STC15xx_Exti.c
  group USER
    ./: main.c stc15xx_it.c
  group MyDriver
    ../MyDriver/: UART.c GPIO.c Exti.c
