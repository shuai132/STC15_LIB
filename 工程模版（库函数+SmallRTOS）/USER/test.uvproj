# Keil uVision project test.uvproj, settings and files
target Target 1 (MCS-51)
  device: 8052AH Intel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(12000000)
  output: test +hex
  c flags: Optimize=7 SizeSpeed=1
  c include: ..\MyDriver;..\Lib\inc;..\Lib\src
  group os
    ../os/: Os_core.c
    ../OS/: Os_q.c Os_sem.c
  group user
    ./: main.c
  group Target CPU
    ../keilc51/: Os_cpu_c.c Os_cpu_a.asm
  group Lib
    ../Lib/src/: STC15xx_GPIO.c STC15xx_USART1.C
  group MyDriver
    ../MyDriver/: UART.c GPIO.c
